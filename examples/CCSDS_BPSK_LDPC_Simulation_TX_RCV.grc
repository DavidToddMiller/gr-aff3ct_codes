options:
  parameters:
    generate_options: qt_gui
    id: LDPC_TX_RCV
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: G
  id: variable_ldpc_G_matrix_def
  parameters:
    filename: /home/davem/gr-aff3ct_codes/G_matrix_ccsds_ar4ja_r1_2_k1024.alist
  states: {}
- name: constel
  id: variable_constellation
  parameters:
    const_points: digital.psk_2()[0]
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_2()[1]
    type: calcdist
  states: {}
- name: ldpc_enc_G
  id: variable_ldpc_encoder_G_def
  parameters:
    G: G
    ndim: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: aff3ct_codes_Frame_ExtractOQPSK_0
  id: aff3ct_codes_Frame_ExtractOQPSK
  parameters:
    ASM_length: '64'
    buffer_length: '30000'
    frame_length: '2112'
  states: {}
- name: aff3ct_codes_Resolve_Phase2_0
  id: aff3ct_codes_Resolve_Phase2
  parameters:
    buffer_length: '30000'
    frame_length: '2112'
    threshold: '3'
    waveform: '1'
  states: {}
- name: aff3ct_codes_Tag_FrameASM64_ff_0
  id: aff3ct_codes_Tag_FrameASM64_ff
  parameters:
    ASM_length: '64'
    threshold: '2'
    waveform: '1'
  states: {}
- name: aff3ct_codes_ccsds_ldpc_decoder_0
  id: aff3ct_codes_ccsds_ldpc_decoder
  parameters:
    code_rate: '1'
    data_rate: 'True'
    decoder_iterations: '40'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: 2.75/4
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/davem/AFF3CT_GithubTest/gr-aff3ct_codes/examples/CCSDS_LDPC_SINK
    type: byte
  states: {}
- name: blocks_file_source_0_0_0_0_0
  id: blocks_file_source
  parameters:
    affinity: '1'
    file: /home/davem/AFF3CT_GithubTest/gr-aff3ct_codes/examples/64_BIT_ASM_CCSDS_LDPC
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_0_0_0_0_0_0
  id: blocks_file_source
  parameters:
    affinity: '1'
    file: /home/davem/AFF3CT_GithubTest/gr-aff3ct_codes/examples/10_CCSDSframes_Before_LDPC_Encode
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '1.0'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_2_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1.0'
    type: complex
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_stream_demux_0
  id: blocks_stream_demux
  parameters:
    lengths: (64,2048)
    type: float
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (64, 2048)
    type: byte
  states: {}
- name: blocks_tag_gate_1
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: constel
    differential: 'False'
    excess_bw: '0.5'
    samples_per_symbol: '2'
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: 2*3.14159/1000
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: '32'
    init_phase: '0'
    loop_bw: 3.14159/100.0
    max_dev: '1.5'
    osps: '1'
    sps: '2'
    taps: firdes.root_raised_cosine(32,64,1.0,0.5,1704)
    type: ccf
  states: {}
- name: fec_extended_encoder_0_0
  id: fec_extended_encoder
  parameters:
    encoder_list: ldpc_enc_G
    puncpat: '11'
    threadtype: none
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 1,0
    legend: 'False'
    name: BPSK constellation
    size: '1024'
    type: complex
    update_time: '0.50'
  states: {}

connections:
- [aff3ct_codes_Frame_ExtractOQPSK_0, '0', aff3ct_codes_Resolve_Phase2_0, '0']
- [aff3ct_codes_Resolve_Phase2_0, '0', blocks_stream_demux_0, '0']
- [aff3ct_codes_Tag_FrameASM64_ff_0, '0', aff3ct_codes_Frame_ExtractOQPSK_0, '0']
- [aff3ct_codes_ccsds_ldpc_decoder_0, '0', blocks_file_sink_0_0, '0']
- [analog_const_source_x_0, '0', aff3ct_codes_Frame_ExtractOQPSK_0, '1']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_throttle2_0, '0']
- [blocks_complex_to_real_0, '0', aff3ct_codes_Tag_FrameASM64_ff_0, '0']
- [blocks_file_source_0_0_0_0_0, '0', blocks_stream_mux_0, '0']
- [blocks_file_source_0_0_0_0_0_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_multiply_const_vxx_2, '0', digital_pfb_clock_sync_xxx_0, '0']
- [blocks_multiply_const_vxx_2_0, '0', blocks_complex_to_real_0, '0']
- [blocks_pack_k_bits_bb_0, '0', digital_constellation_modulator_0_0, '0']
- [blocks_stream_demux_0, '0', blocks_null_sink_1, '0']
- [blocks_stream_demux_0, '1', aff3ct_codes_ccsds_ldpc_decoder_0, '0']
- [blocks_stream_mux_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_tag_gate_1, '0', blocks_multiply_const_vxx_2_0, '0']
- [blocks_throttle2_0, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_unpack_k_bits_bb_0, '0', fec_extended_encoder_0_0, '0']
- [digital_constellation_modulator_0_0, '0', blocks_add_xx_0, '0']
- [digital_costas_loop_cc_0_0, '0', blocks_tag_gate_1, '0']
- [digital_costas_loop_cc_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_costas_loop_cc_0_0, '0']
- [fec_extended_encoder_0_0, '0', blocks_stream_mux_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
