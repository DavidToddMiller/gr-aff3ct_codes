options:
  parameters:
    author: From gr-satellites Originally
    generate_options: qt_gui
    id: SQPSK_ldpc
    output_language: python
    run_options: run
    title: SQPSK demodulator
  states: {}

blocks:
- name: baudrate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1024000*2
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate/baudrate
  states: {}
- name: aff3ct_codes_CCSDS_Pseudo_Randomizer_0
  id: aff3ct_codes_CCSDS_Pseudo_Randomizer
  parameters:
    bits_per_byte: '1'
    count: '2048'
    length: '7'
  states: {}
- name: aff3ct_codes_Frame_ExtractOQPSK_0
  id: aff3ct_codes_Frame_ExtractOQPSK
  parameters:
    ASM_length: '64'
    buffer_length: '30000'
    frame_length: '2112'
  states: {}
- name: aff3ct_codes_Resolve_Phase2_0
  id: aff3ct_codes_Resolve_Phase2
  parameters:
    buffer_length: '30000'
    frame_length: '2112'
    threshold: '7'
    waveform: '1'
  states: {}
- name: aff3ct_codes_Tag_FrameASM64_ff_0
  id: aff3ct_codes_Tag_FrameASM64_ff
  parameters:
    ASM_length: '64'
    threshold: '1'
    waveform: '1'
  states: {}
- name: aff3ct_codes_Tag_FrameASM64_ff_0_0
  id: aff3ct_codes_Tag_FrameASM64_ff
  parameters:
    ASM_length: '64'
    threshold: '1'
    waveform: '1'
  states: {}
- name: aff3ct_codes_ccsds_ldpc_decoder_0
  id: aff3ct_codes_ccsds_ldpc_decoder
  parameters:
    code_rate: '1'
    data_rate: 'True'
    decoder_iterations: '40'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '2'
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/davem/AFF3CT_GithubTest/gr-aff3ct_codes/examples/Test_LDPC_Sink
    type: byte
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/davem/AFF3CT_GithubTest/gr-aff3ct_codes/examples/Before_LDPC_Decode_Sink
    type: byte
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/davem/gr-aff3ct_codes/examples/AllenTelescopeArray1minuteRecordingOnly_QPSK_LDPC_OrionMOON_RF_IQ
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: float
  states: {}
- name: blocks_interleave_0_0
  id: blocks_interleave
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_stream_demux_0
  id: blocks_stream_demux
  parameters:
    lengths: (64, 2048)
    type: float
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: float
  states: {}
- name: blocks_tag_gate_0_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_binary_slicer_fb_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_costas_loop_cc_0_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: '1e-4'
  states: {}
- name: digital_symbol_sync_xx_0_0_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '1e-3'
    max_dev: '0.001'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '4'
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1/4]*4'
    type: ccc
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    alpha1: '1'
    gui_hint: 0,1,1,1
    name: OQPSK constellation
    size: '512'
    type: complex
    update_time: '0.30'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '128'
    srate: samp_rate
    type: float
    update_time: '0.5'
  states: {}

connections:
- [aff3ct_codes_CCSDS_Pseudo_Randomizer_0, '0', aff3ct_codes_ccsds_ldpc_decoder_0, '0']
- [aff3ct_codes_CCSDS_Pseudo_Randomizer_0, '0', digital_binary_slicer_fb_0_0, '0']
- [aff3ct_codes_Frame_ExtractOQPSK_0, '0', aff3ct_codes_Resolve_Phase2_0, '0']
- [aff3ct_codes_Resolve_Phase2_0, '0', blocks_stream_demux_0, '0']
- [aff3ct_codes_Tag_FrameASM64_ff_0, '0', aff3ct_codes_Frame_ExtractOQPSK_0, '0']
- [aff3ct_codes_Tag_FrameASM64_ff_0_0, '0', aff3ct_codes_Frame_ExtractOQPSK_0, '1']
- [aff3ct_codes_ccsds_ldpc_decoder_0, '0', blocks_file_sink_0, '0']
- [blocks_complex_to_float_0, '0', blocks_interleave_0, '0']
- [blocks_complex_to_float_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_complex_to_float_0, '1', blocks_delay_0, '0']
- [blocks_complex_to_float_0, '1', blocks_interleave_0, '1']
- [blocks_complex_to_float_0_0, '0', blocks_delay_0_0, '0']
- [blocks_complex_to_float_0_0, '1', blocks_float_to_complex_0_0, '1']
- [blocks_delay_0, '0', blocks_interleave_0_0, '0']
- [blocks_delay_0_0, '0', blocks_float_to_complex_0_0, '0']
- [blocks_file_source_0_0, '0', blocks_throttle_0, '0']
- [blocks_float_to_complex_0_0, '0', fir_filter_xxx_0_0, '0']
- [blocks_interleave_0, '0', blocks_tag_gate_0_0, '0']
- [blocks_interleave_0_0, '0', blocks_tag_gate_0, '0']
- [blocks_interleave_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_interleave_0_0, '1']
- [blocks_pack_k_bits_bb_0_0, '0', blocks_file_sink_1, '0']
- [blocks_stream_demux_0, '0', blocks_null_sink_1, '0']
- [blocks_stream_demux_0, '1', aff3ct_codes_CCSDS_Pseudo_Randomizer_0, '0']
- [blocks_tag_gate_0, '0', aff3ct_codes_Tag_FrameASM64_ff_0_0, '0']
- [blocks_tag_gate_0_0, '0', aff3ct_codes_Tag_FrameASM64_ff_0, '0']
- [blocks_throttle_0, '0', digital_costas_loop_cc_0_0_0, '0']
- [digital_binary_slicer_fb_0_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [digital_costas_loop_cc_0_0_0, '0', blocks_complex_to_float_0_0, '0']
- [digital_symbol_sync_xx_0_0_0_0, '0', blocks_complex_to_float_0, '0']
- [digital_symbol_sync_xx_0_0_0_0, '0', qtgui_const_sink_x_0, '0']
- [fir_filter_xxx_0_0, '0', digital_symbol_sync_xx_0_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
