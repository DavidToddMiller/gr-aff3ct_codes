options:
  parameters:
    description: DVB-S2 Physical Layer (PL) Synchronization
    generate_options: qt_gui
    id: dvbs2_pl_sync
    output_language: python
    title: DVB-S2 PL Sync
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: snr
  id: variable_qtgui_range
  parameters:
    label: SNR (dB)
    start: '0'
    step: '0.1'
    stop: '20'
    value: '10'
  states: {}
- name: aff3ct_codes_dvbs2_ldpc_decoder_0
  id: aff3ct_codes_dvbs2_ldpc_decoder
  parameters:
    code_rate: '1'
    data_rate: 'True'
    decoder_iterations: '30'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/davem/AFF3CT_GithubTest/gr-aff3ct_codes/examples/Sink_After Decode_DVBS2_test1
    type: byte
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/davem/AFF3CT_GithubTest/gr-aff3ct_codes/examples/Sink_BEFORE_ Decode_DVBS2_test1
    type: byte
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/davem/AFF3CT_GithubTest/gr-aff3ct_codes/examples/10_CCSDSframes_Before_LDPC_Encode
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (127, 1)
    type: float
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: dtv_dvb_ldpc_bb_0
  id: dtv_dvb_ldpc_bb
  parameters:
    constellation: MOD_OTHER
    framesize2: FECFRAME_NORMAL
    rate3: C1_2
    standard: STANDARD_DVBS2
  states: {}

connections:
- [aff3ct_codes_dvbs2_ldpc_decoder_0, '0', blocks_file_sink_0, '0']
- [analog_const_source_x_0, '0', blocks_stream_mux_0, '0']
- [analog_const_source_x_0_0, '0', blocks_stream_mux_0, '1']
- [blocks_add_const_vxx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_char_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_file_source_0_0, '0', blocks_throttle2_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_xx_0, '0', aff3ct_codes_dvbs2_ldpc_decoder_0, '0']
- [blocks_multiply_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_stream_mux_0, '0', blocks_multiply_xx_0, '1']
- [blocks_throttle2_0_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', dtv_dvb_ldpc_bb_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [dtv_dvb_ldpc_bb_0, '0', blocks_char_to_float_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
